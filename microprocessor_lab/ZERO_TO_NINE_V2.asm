LXI SP,3FFFH
LXI H,3500H
MOV A,M
STA 34FFH
PUSH H
START: CALL CLEAR
XRA A
MOV B,A
MVI A,01H
LXI H,34FEH
CALL OUTPUT
MVI C,04H
LOOP1: LXI D,0000H
CALL DELAY
DCR C
JNZ LOOP1
CALL CLEAR
POP H
INX H
MOV A,M
STA 34FFH
PUSH H
MVI A,0AH
CMP L
JNZ START
HLT
